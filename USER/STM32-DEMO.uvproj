# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\APP;..\BSP;..\UCOSII\Ports;..\UCOSII\Source;D:\Keil\C51\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group UCOSII
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ports
    ../UCOSII/Ports/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group BSP
    ../BSP/: BSP.c led.c io_in_out.c uart.c
  group APP
    ../APP/: app_cfg.h os_cfg.h app.c recover.c comm.c
